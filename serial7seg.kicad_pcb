# Repository fivevolts/serial7segKiCAD

## KiCad design serial7seg.kicad_pcb

Parts:
AFF1: 7SEGMENTS
CK1, CK2: CONN_1
GND1, GND2: CONN_1
R1, R2, R3, R4, R5, R6, R7, R8: 150
SIN1: CONN_1
SOUT1: CONN_1
U1: 74LS164
VCC1, VCC2: CONN_1

Connections:
GND: AFF1.3 (C.A.), GND1.1, GND2.1, U1.7
unnamed: R2.2, SOUT1.1, U1.13
unnamed: SIN1.1, U1.1, U1.2
unnamed: R3.2, U1.4
unnamed: AFF1.5 (DP), R8.1
unnamed: R8.2, U1.3
unnamed: R5.2, U1.6
unnamed: R4.2, U1.5
unnamed: AFF1.4 (c), R3.1
unnamed: AFF1.7 (a), R1.1
unnamed: R1.2, U1.12
unnamed: AFF1.2 (d), R4.1
unnamed: AFF1.6 (b), R2.1
unnamed: AFF1.9 (f), R6.1
unnamed: R6.2, U1.11
unnamed: AFF1.10 (g), R7.1
unnamed: R7.2, U1.10
unnamed: AFF1.1 (e), R5.1
unnamed: CK1.1, CK2.1, U1.8
VCC: U1.9, U1.14, VCC1.1, VCC2.1

Board: 2 copper layers, 16.8 x 30.0 mm, 20 parts (17 on the bottom side), 20 nets.

Other parts of the board:
Hole2mm, Hole2mm0: P***; Hole2mm

## Commit log

2014-08-03 double layer solution
